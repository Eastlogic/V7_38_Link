<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\V7_38_Link.ewp</path>
  </project>
  <batchBuild/>
</workspace>


